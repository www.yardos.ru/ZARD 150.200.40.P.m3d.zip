# KOMPAS-3D part (ZARD 150.200.40.P.m3d)

Model tree:
1. Булева операция:1
